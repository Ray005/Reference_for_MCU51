# Keil uVision project final.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: final +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\05大实验
  group Source Group 1
    ./: main.c disp.c delay.c key.c pwm.c UART.c safe.c temp.c
